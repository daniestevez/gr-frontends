options:
  parameters:
    author: Daniel Estevez
    category: Custom
    description: Streams an audio source
    generate_options: no_gui
    id: audio_streamer
    output_language: python
    run_options: run
    title: Audio source streamer
  states: {}

blocks:
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: device
    samp_rate: '48000'
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: destination
    port: port
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: destination
  id: parameter
  parameters:
    label: destination
    type: str
    value: localhost
  states: {}
- name: device
  id: parameter
  parameters:
    label: device
    type: str
    value: ''
  states: {}
- name: port
  id: parameter
  parameters:
    label: port
    type: intx
    value: '7355'
  states: {}

connections:
- [audio_source_0, '0', blocks_float_to_short_0, '0']
- [blocks_float_to_short_0, '0', blocks_udp_sink_0, '0']

metadata:
  file_format: 1
