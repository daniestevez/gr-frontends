options:
  parameters:
    author: Daniel Estevez
    category: Custom
    description: Streams a WAV 44.1kHz file
    generate_options: no_gui
    id: wav_44kHz
    output_language: python
    run_options: run
    title: 'WAV 44.1KHz file streamer '
  states: {}

blocks:
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '48000'
    type: short
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: destination
    port: port
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: input_file
    repeat: 'False'
  states: {}
- name: destination
  id: parameter
  parameters:
    label: destination
    type: str
    value: localhost
  states: {}
- name: input_file
  id: parameter
  parameters:
    label: file
    short_id: f
    type: str
    value: ''
  states: {}
- name: note_0
  id: note
  parameters:
    note: Only 44.1kHz wav
  states: {}
- name: port
  id: parameter
  parameters:
    label: port
    type: intx
    value: '7355'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '147'
    interp: '160'
    taps: ''
    type: fff
  states: {}

connections:
- [blocks_float_to_short_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_udp_sink_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_short_0, '0']

metadata:
  file_format: 1
