options:
  parameters:
    author: Daniel Estevez
    category: Custom
    description: Receives with an Airspy and streams the FM audio
    generate_options: no_gui
    id: airspy_fm
    output_language: python
    run_options: run
    title: FM/FSK receiver for an Airspy device
  states: {}

blocks:
- name: doppler_freq
  id: variable
  parameters:
    value: freq
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '0.2'
  states: {}
- name: bb_gain
  id: parameter
  parameters:
    label: baseband gain
    type: eng_float
    value: '20'
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: destination
    port: port
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: destination
  id: parameter
  parameters:
    label: destination
    type: str
    value: localhost
  states: {}
- name: filter_width
  id: parameter
  parameters:
    label: FM filter width
    type: eng_float
    value: '20000'
  states: {}
- name: freq
  id: parameter
  parameters:
    label: frequency
    short_id: f
    type: eng_float
    value: '0'
  states: {}
- name: freq_corr
  id: parameter
  parameters:
    label: frequency correction (ppm)
    type: eng_float
    value: '0'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: doppler_freq-freq+offset
    decim: '50'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, filter_width/2.0, filter_width/20.0)
    type: ccc
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: localhost
    gpredict_port: gpredict_port
    target: doppler_freq
    verbose: 'False'
  states: {}
- name: gpredict_port
  id: parameter
  parameters:
    label: GPredict port
    type: intx
    value: '4532'
  states: {}
- name: if_gain
  id: parameter
  parameters:
    label: IF gain
    type: eng_float
    value: '20'
  states: {}
- name: offset
  id: parameter
  parameters:
    label: centre frequency offset
    type: eng_float
    value: 50e3
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: rtl
    bb_gain0: bb_gain
    corr0: freq_corr
    freq0: freq-offset
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: ''
    type: fc32
  states: {}
- name: port
  id: parameter
  parameters:
    label: port
    type: intx
    value: '7355'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '24'
    taps: ''
    type: ccc
  states: {}
- name: rf_gain
  id: parameter
  parameters:
    label: RF gain
    type: eng_float
    value: '40'
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_float_to_short_0, '0']
- [blocks_float_to_short_0, '0', blocks_udp_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_xxx_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_quadrature_demod_cf_0, '0']

metadata:
  file_format: 1
